Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: 7 мини.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[720]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[721]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[722]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[723]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[724]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[725]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[726]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[727]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[728]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[729]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[730]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[731]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[732]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[733]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[734]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[735]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[736]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[737]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[738]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[739]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[740]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[741]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[742]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[743]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[744]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[745]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[746]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[747]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[748]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[749]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[750]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[751]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[752]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[753]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[754]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[755]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[756]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[757]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 мини.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
